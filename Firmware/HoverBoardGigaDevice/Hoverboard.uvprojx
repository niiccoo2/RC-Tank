# Keil uVision project Hoverboard.uvprojx, settings and files
target GD32F130 (6240000::V6.24::ARMCLANG)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hoverboard +hex
  AfterMake: fromelf.exe --bin Objects\hoverboard.axf --output BinariesToFlash\hoverboard.bin
  AfterMake: moveOutput.bat
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: GD32F130 TARGET=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Src
    ./Src/: main.c bldc.c driver.c bldcBC.c bldcSINE.c setup.c it.c led.c comms.c remoteUart.c remoteCrsf.c remoteDummy.c remoteUartBus.c remoteOptimizePID.c commsMasterSlave.c RemoteAdc.c RemoteAutodetect.c RemoteROS2.c i2c.c mpu6050.c imuMPU6050.c bmi160.c PilotHoverbike.c PilotUser.c SEGGER_RTT.c
  group Inc
    ./Inc/: configSelect.h config.h configDebug.h setup.h bldc.h bldcBC.h bldcSINE.h it.h led.h target.h remote.h remoteUart.h remoteCrsf.h remoteDummy.h remoteUartBus.h RemoteAdc.h remoteAutodetect.h RemoteROS2.h comms.h commsMasterSlave.h defines.h i2c.h mpu6050.h PilotHoverbike.h PilotUser.h
  group defines
    ./Inc/defines/: defines_2-1-1.h defines_2-1-2.h defines_2-1-3.h defines_2-1-4.h defines_2-1-5.h defines_2-1-6.h defines_2-1-7.h defines_2-1-8.h defines_2-1-9.h defines_2-1-10.h defines_2-1-11.h defines_2-1-12.h defines_2-1-13.h defines_2-1-14.h defines_2-1-15.h defines_2-1-16.h defines_2-1-18.h defines_2-1-20.h defines_2-1-22.h defines_2-2-1.h defines_2-2-3.h defines_2-2-6.h defines_2-2-7.h defines_2-3-1.h defines_2-3-2.h defines_2-4-1.h defines_2-ad.h defines_2-x-y.h defines_2-3-3.h
    ./: 2-1-9.h
target GD32F103 (6240000::V6.24::ARMCLANG)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hoverboard +hex
  AfterMake: as above
  AfterMake: moveOutput.bat
  c flags: Optim=7 v6Lang=3 v6LangP=5 wLevel=3
  c define: GD32F103 TARGET=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target GD32E230 (6240000::V6.24::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Hoverboard +hex
  AfterMake: as above
  AfterMake: moveOutput.bat
  c flags: Optim=7 v6Lang=3 v6LangP=5 wLevel=3
  c define: GD32E230 TARGET=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target MM32SPIN05 (6240000::V6.24::ARMCLANG)
  device: MM32SPIN05PF MindMotion
  pack: MindMotion.MM32SPIN0x_DFP.1.0.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Hoverboard +hex
  AfterMake: as above
  AfterMake: moveOutput.bat
  c flags: Optim=2 v6Lang=1 v6LangP=5 wLevel=3
  c define: MM32SPIN05 TARGET=4
  c include: .\RTE\IncludeMM32;.\Device\MM32SPIN0x_q\HAL_Lib\Inc;.\Device\CMSIS\KEIL_Core
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
software components: CMSIS:CORE 6.0.0, CMSIS:CORE 6.1.0, Device:GD32E23x_StdPeripherals:ADC 1.0.0, Device:GD32E23x_StdPeripherals:DMA 1.0.0, Device:GD32E23x_StdPeripherals:EXTI 1.0.0, Device:GD32E23x_StdPeripherals:FMC 1.0.0, Device:GD32E23x_StdPeripherals:FWDGT 1.0.0, Device:GD32E23x_StdPeripherals:GPIO 1.0.0, Device:GD32E23x_StdPeripherals:I2C 1.0.0, Device:GD32E23x_StdPeripherals:MISC 1.0.0, Device:GD32E23x_StdPeripherals:PMU 1.0.0, Device:GD32E23x_StdPeripherals:RCU 1.0.0, Device:GD32E23x_StdPeripherals:SYSCFG 1.0.0, Device:GD32E23x_StdPeripherals:TIMER 1.0.0, Device:GD32E23x_StdPeripherals:USART 1.0.0, Device:GD32E23x_StdPeripherals:WWDGT 1.0.0, Device:GD32E23x_libopt 1.0.0, Device:GD32F10x_StdPeripherals:ADC 2.0.1, Device:GD32F10x_StdPeripherals:DMA 2.0.1, Device:GD32F10x_StdPeripherals:EXTI 2.0.1, Device:GD32F10x_StdPeripherals:FMC 2.0.1, Device:GD32F10x_StdPeripherals:FWDGT 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:I2C 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_StdPeripherals:TIMER 2.0.1, Device:GD32F10x_StdPeripherals:USART 2.0.1, Device:GD32F10x_StdPeripherals:WWDGT 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:GD32F1x0_StdPeripherals:ADC 3.2.0, Device:GD32F1x0_StdPeripherals:DMA 3.2.0, Device:GD32F1x0_StdPeripherals:EXTI 3.2.0, Device:GD32F1x0_StdPeripherals:FMC 3.2.0, Device:GD32F1x0_StdPeripherals:FWDGT 3.2.0, Device:GD32F1x0_StdPeripherals:GPIO 3.2.0, Device:GD32F1x0_StdPeripherals:I2C 3.2.0, Device:GD32F1x0_StdPeripherals:MCUDBG 3.2.0, Device:GD32F1x0_StdPeripherals:MISC 3.2.0, Device:GD32F1x0_StdPeripherals:OPA 3.2.0, Device:GD32F1x0_StdPeripherals:PMU 3.2.0, Device:GD32F1x0_StdPeripherals:RCU 3.2.0, Device:GD32F1x0_StdPeripherals:SYSCFG 3.2.0, Device:GD32F1x0_StdPeripherals:TIMER 3.2.0, Device:GD32F1x0_StdPeripherals:USART 3.2.0, Device:GD32F1x0_StdPeripherals:WWDGT 3.2.0, Device:GD32F1x0_libopt 3.2.0, Device:Startup 1.0.0, Device:Startup 2.0.1, Device:Startup 3.2.0, Device:Startup 1.0.0
