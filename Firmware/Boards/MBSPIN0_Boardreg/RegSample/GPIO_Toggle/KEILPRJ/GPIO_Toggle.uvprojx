# Keil uVision project GPIO_Toggle.uvprojx, settings and files
target MM32Series (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32SPIN06PS MindMotion
  pack: MindMotion.MM32SPIN0x_DFP.1.0.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\MM32SPIN06xx_s\Include;..\..\..\..\..\Device\MM32SPIN06xx_s\HAL_Lib\Inc;..\..\..\..\..\Device\CMSIS\KEIL_Core;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group USER
    ../USER/: main.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
